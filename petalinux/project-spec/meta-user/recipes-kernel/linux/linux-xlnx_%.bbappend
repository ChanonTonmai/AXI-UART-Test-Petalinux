SRC_URI += "file://user_2022-12-02-03-59-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

